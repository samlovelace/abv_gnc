Commit message: adds widow-xl manipulator urdf

File: src/abv_description/urdf/abv.urdf (robot description, URDF)
Before this commit: robot abv, 4 links, 3 joints
Links:
- link vehicle_link: geometry visual mesh filename=package://abv_description/meshes/abv_chassis/abv_v2.dae
